# Keil uVision project GUC_dogl128_exemple.uvproj, settings and files
target Kit (MCS-51)
  device: C8051F381 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: GUC_dogl128_exemple
  c flags: SizeSpeed=1
  group Sources
    ./: STARTUP.A51 config.c main.c GUC_dogl128.c
  group Headers
    ./: config.h GUC_dogl128.h
